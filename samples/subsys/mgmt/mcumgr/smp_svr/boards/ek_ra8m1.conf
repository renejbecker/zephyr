## samples/subsys/mgmt/mcumgr/smp_svr/boards/ek_ra8m1.conf
```kconfig
CONFIG_MCUBOOT_EXTRA_IMGTOOL_ARGS="--align 32"

CONFIG_RENESAS_RA_OSPI_B_HEAP_SIZE=4096
CONFIG_HEAP_MEM_POOL_SIZE=2048
```
